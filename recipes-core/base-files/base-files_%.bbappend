FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI:append = " file://fstab"
